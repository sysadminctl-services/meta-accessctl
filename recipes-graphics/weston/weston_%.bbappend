PACKAGECONFIG:append = " xwayland"
RDEPENDS_${PN}:append = " weston-xwayland"
