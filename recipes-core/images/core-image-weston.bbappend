IMAGE_INSTALL:append = "  chromium-ozone-wayland udhcpd-config welcome-script accessctl-user"
