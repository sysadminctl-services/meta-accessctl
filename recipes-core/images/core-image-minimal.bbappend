IMAGE_INSTALL:append = " udhcpd-config welcome-script accessctl-user"
